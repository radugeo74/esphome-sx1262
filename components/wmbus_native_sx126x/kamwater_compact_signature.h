#pragma once
// Exact compact DIF/VIF signature algorithm of upstream wmbusmeters
// src/crypto/crc16.cc: CRC16 EN 13757 polynomial 0x3D65,
// initial 0x0000, MSB first, final bitwise complement.
// This only identifies a format candidate, NOT ELL authenticity/security.
#include <cstddef>
#include <cstdint>
namespace xmq_portable { namespace kamwater { namespace signature {
struct Format {
  const uint8_t *bytes;
  size_t size;
};
inline uint16_t crc16_en13757(const uint8_t *data, size_t size) {
  uint16_t crc=0;
  if (!data && size!=0) return 0;
  for(size_t i=0;i<size;++i) {
    uint8_t byte=data[i];
    for(unsigned bit=0;bit<8;++bit) {
      const bool high=(crc&0x8000u)!=0;
      const bool input=(byte&0x80u)!=0;
      crc=static_cast<uint16_t>((static_cast<uint32_t>(crc)<<1) ^
                                 ((high!=input)?0x3D65u:0u));
      byte=static_cast<uint8_t>(byte<<1);
    }
  }
  return static_cast<uint16_t>(~crc);
}
inline const Format *formats(size_t &count) {
  static constexpr uint8_t p0[]={0x02,0xFF,0x20,0x04,0x13,0x44,0x13,0x61,0x5B,0x61,0x67};
  static constexpr uint8_t p1[]={0x02,0xFF,0x20,0x04,0x13,0x92,0x01,0x3B,0xA1,0x01,0x5B,0x81,0x01,0xE7,0xFF,0x0F};
  static constexpr uint8_t p2[]={0x04,0xFF,0x23,0x44,0x13,0x52,0x3B,0x06,0xFF,0x1B,0x42,0x6C,0x61,0x67,0x51,0x67,0x02,0x3B,0x04,0x13,0x81,0x01,0xE7,0xFF,0x0F};
  static constexpr uint8_t p3[]={0x02,0xFF,0x20,0x04,0x13,0x44,0x13,0x42,0x6C,0x52,0x3B,0x61,0x5B,0x61,0x67,0x51,0x67,0x81,0x01,0xE7,0xFF,0x0F,0x06,0xFF,0x1B};
  static constexpr uint8_t p4[]={0x02,0xFF,0x20,0x04,0x13,0x44,0x13,0xA1,0x01,0x5B,0x81,0x01,0xE7,0xFF,0x0F};
  static constexpr uint8_t p5[]={0x02,0xFF,0x20,0x04,0x13,0x44,0x13,0x61,0x5B,0x51,0x67};
  static constexpr uint8_t p6[]={0x02,0xFF,0x20,0x04,0x13,0x44,0x13};
  static constexpr uint8_t p7[]={0x02,0xFF,0x20,0x04,0x13,0x52,0x3B};
  static constexpr uint8_t p8[]={0x04,0xFF,0x23,0x04,0x13,0x44,0x13,0x42,0x6C,0x02,0x3B,0x92,0x01,0x3B,0xA2,0x01,0x3B,0x06,0xFF,0x1B,0xA1,0x01,0x5B,0x91,0x01,0x5B,0xA1,0x01,0x67};
  static const Format table[]={
    {p0,sizeof(p0)},{p1,sizeof(p1)},{p2,sizeof(p2)},
    {p3,sizeof(p3)},{p4,sizeof(p4)},{p5,sizeof(p5)},
    {p6,sizeof(p6)},{p7,sizeof(p7)},{p8,sizeof(p8)}
  };
  count=sizeof(table)/sizeof(table[0]);
  return table;
}
enum class Result : uint8_t { Matched, Unknown, Ambiguous };
inline Result identify(uint16_t observed_signature, int &index) {
  index=-1;
  size_t count=0;
  const Format *table=formats(count);
  for(size_t i=0;i<count;++i) {
    if (crc16_en13757(table[i].bytes,table[i].size)!=observed_signature)
      continue;
    if(index!=-1) {index=-1;return Result::Ambiguous;}
    index=static_cast<int>(i);
  }
  return index<0?Result::Unknown:Result::Matched;
}
}}} // namespace xmq_portable::kamwater::signature
